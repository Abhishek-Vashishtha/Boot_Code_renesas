# IAR project Backup of GDEV72.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10NPJ RL78 - R5F10NPJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1240
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: source_code\driver_files; source_code\library_files; source_code\misc_files; source_code\source_files
  ARL78.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: GDEV72_BOOT.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkIcfFile: source_code\misc_files\lnkr5f10npj.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group driver_files
    source_code/driver_files/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_lcd.c r_cg_lcd.h r_cg_lvd.c r_cg_lvd.h r_cg_lvd_user.c r_cg_macrodriver.h r_cg_port.h r_cg_sau.c r_cg_sau.h r_cg_sau_user.c r_cg_systeminit.c r_cg_wdt.c r_cg_wdt.h r_cg_wdt_user.c
  group library_files
    source_code/library_files/: fsl.a fsl.h fsl_types.h
  group misc_files
    source_code/misc_files/: lnkr5f10npj.icf
  group source_files
    source_code/source_files/: clock.c clock.h common_function.c common_function.h Flash_Protocol.c Flash_Protocol.h lcd.c lcd.h main.c main.h pcb.c pcb.h sleep.c sleep.h system.c system.h variables.h wdt.c wdt.h
